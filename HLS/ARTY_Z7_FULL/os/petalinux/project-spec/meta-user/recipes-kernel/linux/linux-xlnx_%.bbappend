SRC_URI += "file://user_2017-06-28-14-10-00.cfg \
            file://user_2017-06-28-14-37-00.cfg \
            file://user_2017-06-28-15-16-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

