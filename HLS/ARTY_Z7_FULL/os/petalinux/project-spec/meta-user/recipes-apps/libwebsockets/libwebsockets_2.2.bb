require libwebsockets.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=b44d8de2acfd19cc7f43d7ed14bef2d8"

