IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " smartio"
IMAGE_INSTALL_append = " lsuio"
IMAGE_INSTALL_append = " libsmart"
IMAGE_INSTALL_append = " focserver"
IMAGE_INSTALL_append = " libuv"
IMAGE_INSTALL_append = " libwebsockets"
IMAGE_INSTALL_append = " focinit"
IMAGE_INSTALL_append = " libjsoncpp"
