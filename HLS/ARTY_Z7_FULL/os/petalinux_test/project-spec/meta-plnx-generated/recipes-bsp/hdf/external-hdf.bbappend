
HDF_BASE = "file://"
HDF_PATH = "${TOPDIR}/../project-spec/hw-description/system.hdf"
