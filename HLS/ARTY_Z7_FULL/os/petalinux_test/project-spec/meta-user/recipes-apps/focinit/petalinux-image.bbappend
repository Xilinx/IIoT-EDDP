IMAGE_INSTALL_append = " focinit"
