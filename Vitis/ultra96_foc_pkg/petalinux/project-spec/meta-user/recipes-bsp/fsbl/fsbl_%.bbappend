#Add debug for FSBL
XSCTH_BUILD_DEBUG = "1"
