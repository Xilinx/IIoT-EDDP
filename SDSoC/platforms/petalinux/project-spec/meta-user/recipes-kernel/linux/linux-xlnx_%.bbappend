SRC_URI += "file://user_2017-08-23-15-36-00.cfg \
            file://user_2017-08-23-16-17-00.cfg \
            file://user_2017-08-23-16-20-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

